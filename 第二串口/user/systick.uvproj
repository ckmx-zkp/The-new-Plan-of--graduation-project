# Keil uVision project systick.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: systick
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\user;..\stm32f0;..\drive;..\lib\inc;..\lib\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: startup_stm32f0xx.s
    ../stm32f0/: system_stm32f0xx.c stm32f0xx_it.c
  group user
    ./: main.c
  group drive
    ../drive/: systick.c adc.c timer.c usart.c mlx90614.c
    ./: usart2.c
  group lib
    ../lib/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_adc.c stm32f0xx_exti.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_rtc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
